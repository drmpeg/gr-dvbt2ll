<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vv009_4kfft</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>3429e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>(8000000.0 * 8) / 7</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>70</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>89</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga1_gain</value></param>
<param><key>value</key><value>-8</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-35</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-4</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga2_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>0.2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dtv_dvb_ldpc_bb</key>
<param><key>id</key><value>dtv_dvb_ldpc_bb_0</value></param>
<param><key>rate2</key><value>C4_5</value></param>
<param><key>framesize1</key><value>FECFRAME_SHORT</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dvbt2ll_bbheaderbch_bb</key>
<param><key>id</key><value>dvbt2ll_bbheaderbch_bb_0</value></param>
<param><key>mode</key><value>INPUTMODE_NORMAL</value></param>
<param><key>rate</key><value>C4_5</value></param>
<param><key>fecblocks</key><value>168</value></param>
<param><key>framesize</key><value>FECFRAME_SHORT</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
<param><key>tsrate</key><value>4000000</value></param>
</block>
<block>
<key>dvbt2ll_framemapperfint_cc</key>
<param><key>id</key><value>dvbt2ll_framemapperfint_cc_0</value></param>
<param><key>inputmode</key><value>INPUTMODE_NORMAL</value></param>
<param><key>rate</key><value>C4_5</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>carriermode</key><value>CARRIERS_NORMAL</value></param>
<param><key>fecblocks</key><value>8</value></param>
<param><key>framesize</key><value>FECFRAME_SHORT</value></param>
<param><key>fftsize1</key><value>FFTSIZE_4K</value></param>
<param><key>fftsize2</key><value>FFTSIZE_2K</value></param>
<param><key>guardinterval</key><value>GI_1_32</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
<param><key>l1constellation</key><value>L1_MOD_64QAM</value></param>
<param><key>l1scrambled</key><value>L1_SCRAMBLED_OFF</value></param>
<param><key>numdatasyms</key><value>3</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>paprmode2</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>preamble2</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>reservedbiasbits</key><value>RESERVED_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>t2frames</key><value>2</value></param>
<param><key>tiblocks</key><value>3</value></param>
</block>
<block>
<key>dvbt2ll_interleavermod_bc</key>
<param><key>id</key><value>dvbt2ll_interleavermod_bc_0</value></param>
<param><key>rate</key><value>C4_5</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>framesize</key><value>FECFRAME_SHORT</value></param>
</block>
<block>
<key>dvbt2ll_pilotgenp1insert_cc</key>
<param><key>id</key><value>dvbt2ll_pilotgenp1insert_cc_0</value></param>
<param><key>bandwidth</key><value>BANDWIDTH_1_7_MHZ</value></param>
<param><key>carriermode</key><value>CARRIERS_NORMAL</value></param>
<param><key>fftsize</key><value>FFTSIZE_4K</value></param>
<param><key>guardinterval</key><value>GI_1_32</value></param>
<param><key>misogroup</key><value>MISO_TX1</value></param>
<param><key>numdatasyms</key><value>3</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>paprmode2</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>preamble2</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>equalization</key><value>EQUALIZATION_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, 4000000)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"send_frame_size=8192,num_send_frames=96,master_clock_rate=" + str(samp_rate*4)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>ule_ule_source</key>
<param><key>id</key><value>ule_ule_source_0_0</value></param>
<param><key>call_sign</key><value>W6RZ</value></param>
<param><key>filename</key><value>dvb_channel.conf</value></param>
<param><key>dst_address</key><value>44.0.0.1</value></param>
<param><key>mac_address</key><value>02:00:48:55:4c:4b</value></param>
<param><key>ping_reply</key><value>PING_REPLY_OFF</value></param>
<param><key>frequency</key><value>472000000</value></param>
<param><key>src_address</key><value>44.0.0.3</value></param>
<param><key>ipaddr_spoof</key><value>IPADDR_SPOOF_OFF</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_ldpc_bb_0</source_block_id><sink_block_id>dvbt2ll_interleavermod_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2ll_bbheaderbch_bb_0</source_block_id><sink_block_id>dtv_dvb_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2ll_framemapperfint_cc_0</source_block_id><sink_block_id>dvbt2ll_pilotgenp1insert_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2ll_interleavermod_bc_0</source_block_id><sink_block_id>dvbt2ll_framemapperfint_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2ll_pilotgenp1insert_cc_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ule_ule_source_0_0</source_block_id><sink_block_id>dvbt2ll_bbheaderbch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
