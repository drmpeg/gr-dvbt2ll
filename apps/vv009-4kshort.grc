options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: vv009_4kshort
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 472e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (8000000.0 * 8) / 7
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.5'
    stop: '89'
    value: '50'
  states: {}
- name: vga1_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '-35'
    step: '1'
    stop: '-4'
    value: '-8'
  states: {}
- name: vga2_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '10'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.2'
    type: complex
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    framesize1: FECFRAME_SHORT
    rate2: C5_6
    standard: STANDARD_DVBT2
  states: {}
- name: dvbt2ll_bbheaderbch_bb_0
  id: dvbt2ll_bbheaderbch_bb
  parameters:
    fecblocks: '168'
    framesize: FECFRAME_SHORT
    inband: INBAND_OFF
    mode: INPUTMODE_NORMAL
    rate: C5_6
    tsrate: '4000000'
  states: {}
- name: dvbt2ll_framemapperfint_cc_0
  id: dvbt2ll_framemapperfint_cc
  parameters:
    carriermode: CARRIERS_NORMAL
    constellation: MOD_256QAM
    fecblocks: '14'
    fftsize1: FFTSIZE_4K
    fftsize2: FFTSIZE_2K
    framesize: FECFRAME_SHORT
    guardinterval: GI_1_32
    inband: INBAND_OFF
    inputmode: INPUTMODE_NORMAL
    l1constellation: L1_MOD_16QAM
    l1scrambled: L1_SCRAMBLED_OFF
    numdatasyms: '7'
    paprmode1: PAPR_OFF
    paprmode2: PAPR_OFF
    pilotpattern: PILOT_PP4
    preamble1: PREAMBLE_T2_SISO
    preamble2: PREAMBLE_T2_SISO
    rate: C5_6
    reservedbiasbits: RESERVED_OFF
    rotation: ROTATION_ON
    t2frames: '2'
    tiblocks: '0'
    version: VERSION_111
  states: {}
- name: dvbt2ll_interleavermod_bc_0
  id: dvbt2ll_interleavermod_bc
  parameters:
    constellation: MOD_256QAM
    framesize: FECFRAME_SHORT
    rate: C5_6
    rotation: ROTATION_ON
  states: {}
- name: dvbt2ll_pilotgenp1insert_cc_0
  id: dvbt2ll_pilotgenp1insert_cc
  parameters:
    bandwidth: BANDWIDTH_1_7_MHZ
    carriermode: CARRIERS_NORMAL
    equalization: EQUALIZATION_OFF
    fftsize: FFTSIZE_4K
    guardinterval: GI_1_32
    misogroup: MISO_TX1
    numdatasyms: '7'
    paprmode1: PAPR_OFF
    paprmode2: PAPR_OFF
    pilotpattern: PILOT_PP4
    preamble1: PREAMBLE_T2_SISO
    preamble2: PREAMBLE_T2_SISO
    version: VERSION_111
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, 4000000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=96,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: none
    type: fc32
  states: {}
- name: ule_ule_source_0_0
  id: ule_ule_source
  parameters:
    call_sign: W6RZ
    dst_address: 44.0.0.1
    filename: dvb_channel.conf
    frequency: '472000000'
    ipaddr_spoof: IPADDR_SPOOF_OFF
    mac_address: 02:00:48:55:4c:4b
    ping_reply: PING_REPLY_ON
    src_address: 44.0.0.3
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dvbt2ll_interleavermod_bc_0, '0']
- [dvbt2ll_bbheaderbch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dvbt2ll_framemapperfint_cc_0, '0', dvbt2ll_pilotgenp1insert_cc_0, '0']
- [dvbt2ll_interleavermod_bc_0, '0', virtual_sink_0, '0']
- [dvbt2ll_pilotgenp1insert_cc_0, '0', blocks_multiply_const_xx_0, '0']
- [ule_ule_source_0_0, '0', dvbt2ll_bbheaderbch_bb_0, '0']
- [virtual_source_0, '0', dvbt2ll_framemapperfint_cc_0, '0']

metadata:
  file_format: 1
